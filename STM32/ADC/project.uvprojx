# Keil uVision project project.uvprojx, settings and files
target project (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=4 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\CMSIS;.\StdPeriphDriver\inc;.\Users\Inc;.\Users\Src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ./CMSIS/: system_stm32f10x.c core_cm3.c
  group StdPeriphDriver
    ./StdPeriphDriver/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_adc.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_usart.c
  group StartUp
    ./StartUp/: startup_stm32f10x_md.s
  group User
    ./Users/Src/: stm32f10x_it.c main.c adc.c printf.c systick.c hwjs.c buz.c ds18b20.c exti2.c exti3.c exti4.c key.c led.c public.c pwm.c smg.c time.c usart232.c usart485.c
software components: CMSIS:CORE 5.0.2
